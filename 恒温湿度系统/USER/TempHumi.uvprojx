# Keil uVision project TempHumi.uvprojx, settings and files
target TempHumi (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TempHumi +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\DHT11;..\HARDWARE\OLED;..\HARDWARE\DISPLAY;..\HARDWARE\RFID;..\HARDWARE\ENCODER;..\HARDWARE\ACTUATOR;..\HARDWARE\CONTROL;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c dht11_filter.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DISPLAY/: display.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/ACTUATOR/: actuator.c
    ../HARDWARE/CONTROL/: control.c fuzzy_pid.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
